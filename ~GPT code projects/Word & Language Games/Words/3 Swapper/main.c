// A minimal Win32 console app

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

int main( void ) {
	long c,p;
	char str [255],word[128],pron[128];
	FILE	*out,*in;	
		
	out = fopen("swapped back all unique.txt", "w");
	if(out == NULL)
	{
		printf("\nCannot open Output File\n");
		exit(0);
	}
	
	in = fopen("swapped no duplicates.txt", "r");
	if(in == NULL)
	{
		printf("\nCannot open Input File\n");
		exit(0);
	}
	
	while(!feof(in))
	{
		fgets(str,255,in);		//	get the entry
		
		sscanf(str,"%s",&word);	//	get the word
		sscanf(&str[strlen(word)],"%s",&pron);	//	get the pronunciation
		
		fprintf(out,"%s ",&pron);
		fprintf(out,"%s\n",&word);

	}

	if(out != NULL)
		fclose(out);
	if(in != NULL)
		fclose(in);
	
	return 0;
}