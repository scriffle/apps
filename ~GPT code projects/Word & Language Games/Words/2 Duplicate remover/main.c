// A minimal Win32 console app

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

int main( void ) {
	long c,p;
	char str [255],word[128],prevword[128],pron[128];
	FILE	*out,*in;	
		
	out = fopen("swapped no duplicates.txt", "w");
	if(out == NULL)
	{
		printf("\nCannot open Output File\n");
		exit(0);
	}
	
	in = fopen("swapped.txt", "r");
	if(in == NULL)
	{
		printf("\nCannot open Input File\n");
		exit(0);
	}
	
	while(!feof(in))
	{
		fgets(str,255,in);		//	get the entry
		
		if(word!=NULL) strcpy (prevword,word);	// save the previous word
		
		sscanf(str,"%s",&word);	//	get the word
		sscanf(&str[strlen(word)],"%s",&pron);	//	get the pronunciation
			
		// look for duplicates	
		if(strcmp(word,prevword)==0){
			printf("%s	%s\n",&word,&prevword);
		}else{
			fprintf(out,"%s ",&word);
			fprintf(out,"%s\n",&pron);
		}
		
	}
	
	if(out != NULL)
		fclose(out);
	if(in != NULL)
		fclose(in);
	
	return 0;
}