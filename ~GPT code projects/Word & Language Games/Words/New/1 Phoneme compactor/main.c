
#include <stdio.h>
#include <stdlib.h>

int main( void ) {
	long c,p;
	char str [255],word[128],phoneme[8];
	FILE	*out,*in;	
		
	out = fopen("modified.txt", "w");
	if(out == NULL)
	{
		printf("\nCannot open Output File\n");
		exit(0);
	}
	
	in = fopen("dict.txt", "r");
	if(in == NULL)
	{
		printf("\nCannot open Input File\n");
		exit(0);
	}
	
	while(!feof(in))
	{
		fgets(str,255,in);		//	get the entry
		
		sscanf(str,"%s",&word);	//	get the word
		printf("%s ",&word);
		fprintf(out,"%s ",&word);
		
		p=strlen(word);
		while(sscanf(&str[p],"%s",&phoneme)!=EOF){	//	get the phonemes
			
			printf("%s ",phoneme);
			
if((strcmp(&phoneme,"AA")==0)||(strcmp(&phoneme,"AA0")==0)||(strcmp(&phoneme,"AA1")==0)||(strcmp(&phoneme,"AA2")==0)) fprintf(out,"(",&word);
if((strcmp(&phoneme,"AE")==0)||(strcmp(&phoneme,"AE0")==0)||(strcmp(&phoneme,"AE1")==0)||(strcmp(&phoneme,"AE2")==0)) fprintf(out,")",&word);
if((strcmp(&phoneme,"AH")==0)||(strcmp(&phoneme,"AH0")==0)||(strcmp(&phoneme,"AH1")==0)||(strcmp(&phoneme,"AH2")==0)) fprintf(out,"[",&word);
if((strcmp(&phoneme,"AO")==0)||(strcmp(&phoneme,"AO0")==0)||(strcmp(&phoneme,"AO1")==0)||(strcmp(&phoneme,"AO2")==0)) fprintf(out,"]",&word);
if((strcmp(&phoneme,"AW")==0)||(strcmp(&phoneme,"AW0")==0)||(strcmp(&phoneme,"AW1")==0)||(strcmp(&phoneme,"AW2")==0)) fprintf(out,"1",&word);
if((strcmp(&phoneme,"AY")==0)||(strcmp(&phoneme,"AY0")==0)||(strcmp(&phoneme,"AY1")==0)||(strcmp(&phoneme,"AY2")==0)) fprintf(out,"2",&word);
if((strcmp(&phoneme,"B")==0)||(strcmp(&phoneme,"B0")==0)||(strcmp(&phoneme,"B1")==0)||(strcmp(&phoneme,"B2")==0)) fprintf(out,"3",&word);
if((strcmp(&phoneme,"CH")==0)||(strcmp(&phoneme,"CH0")==0)||(strcmp(&phoneme,"CH1")==0)||(strcmp(&phoneme,"CH2")==0)) fprintf(out,"4",&word);
if((strcmp(&phoneme,"D")==0)||(strcmp(&phoneme,"D0")==0)||(strcmp(&phoneme,"D1")==0)||(strcmp(&phoneme,"D2")==0)) fprintf(out,"5",&word);
if((strcmp(&phoneme,"DH")==0)||(strcmp(&phoneme,"DH0")==0)||(strcmp(&phoneme,"DH1")==0)||(strcmp(&phoneme,"DH2")==0)) fprintf(out,"6",&word);
if((strcmp(&phoneme,"EH")==0)||(strcmp(&phoneme,"EH0")==0)||(strcmp(&phoneme,"EH1")==0)||(strcmp(&phoneme,"EH2")==0)) fprintf(out,"7",&word);
if((strcmp(&phoneme,"ER")==0)||(strcmp(&phoneme,"ER0")==0)||(strcmp(&phoneme,"ER1")==0)||(strcmp(&phoneme,"ER2")==0)) fprintf(out,"8",&word);
if((strcmp(&phoneme,"EY")==0)||(strcmp(&phoneme,"EY0")==0)||(strcmp(&phoneme,"EY1")==0)||(strcmp(&phoneme,"EY2")==0)) fprintf(out,"9",&word);
if((strcmp(&phoneme,"F")==0)||(strcmp(&phoneme,"F0")==0)||(strcmp(&phoneme,"F1")==0)||(strcmp(&phoneme,"F2")==0)) fprintf(out,"a",&word);
if((strcmp(&phoneme,"G")==0)||(strcmp(&phoneme,"G0")==0)||(strcmp(&phoneme,"G1")==0)||(strcmp(&phoneme,"G2")==0)) fprintf(out,"b",&word);
if((strcmp(&phoneme,"HH")==0)||(strcmp(&phoneme,"HH0")==0)||(strcmp(&phoneme,"HH1")==0)||(strcmp(&phoneme,"HH2")==0)) fprintf(out,"c",&word);
if((strcmp(&phoneme,"IH")==0)||(strcmp(&phoneme,"IH0")==0)||(strcmp(&phoneme,"IH1")==0)||(strcmp(&phoneme,"IH2")==0)) fprintf(out,"d",&word);
if((strcmp(&phoneme,"IY")==0)||(strcmp(&phoneme,"IY0")==0)||(strcmp(&phoneme,"IY1")==0)||(strcmp(&phoneme,"IY2")==0)) fprintf(out,"e",&word);
if((strcmp(&phoneme,"JH")==0)||(strcmp(&phoneme,"JH0")==0)||(strcmp(&phoneme,"JH1")==0)||(strcmp(&phoneme,"JH2")==0)) fprintf(out,"f",&word);
if((strcmp(&phoneme,"K")==0)||(strcmp(&phoneme,"K0")==0)||(strcmp(&phoneme,"K1")==0)||(strcmp(&phoneme,"K2")==0)) fprintf(out,"g",&word);
if((strcmp(&phoneme,"L")==0)||(strcmp(&phoneme,"L0")==0)||(strcmp(&phoneme,"L1")==0)||(strcmp(&phoneme,"L2")==0)) fprintf(out,"h",&word);
if((strcmp(&phoneme,"M")==0)||(strcmp(&phoneme,"M0")==0)||(strcmp(&phoneme,"M1")==0)||(strcmp(&phoneme,"M2")==0)) fprintf(out,"i",&word);
if((strcmp(&phoneme,"N")==0)||(strcmp(&phoneme,"N0")==0)||(strcmp(&phoneme,"N1")==0)||(strcmp(&phoneme,"N2")==0)) fprintf(out,"j",&word);
if((strcmp(&phoneme,"NG")==0)||(strcmp(&phoneme,"NG0")==0)||(strcmp(&phoneme,"NG1")==0)||(strcmp(&phoneme,"NG2")==0)) fprintf(out,"k",&word);
if((strcmp(&phoneme,"OW")==0)||(strcmp(&phoneme,"OW0")==0)||(strcmp(&phoneme,"OW1")==0)||(strcmp(&phoneme,"OW2")==0)) fprintf(out,"l",&word);
if((strcmp(&phoneme,"OY")==0)||(strcmp(&phoneme,"OY0")==0)||(strcmp(&phoneme,"OY1")==0)||(strcmp(&phoneme,"OY2")==0)) fprintf(out,"m",&word);
if((strcmp(&phoneme,"P")==0)||(strcmp(&phoneme,"P0")==0)||(strcmp(&phoneme,"P1")==0)||(strcmp(&phoneme,"P2")==0)) fprintf(out,"n",&word);
if((strcmp(&phoneme,"R")==0)||(strcmp(&phoneme,"R0")==0)||(strcmp(&phoneme,"R1")==0)||(strcmp(&phoneme,"R2")==0)) fprintf(out,"o",&word);
if((strcmp(&phoneme,"S")==0)||(strcmp(&phoneme,"S0")==0)||(strcmp(&phoneme,"S1")==0)||(strcmp(&phoneme,"S2")==0)) fprintf(out,"p",&word);
if((strcmp(&phoneme,"SH")==0)||(strcmp(&phoneme,"SH0")==0)||(strcmp(&phoneme,"SH1")==0)||(strcmp(&phoneme,"SH2")==0)) fprintf(out,"q",&word);
if((strcmp(&phoneme,"T")==0)||(strcmp(&phoneme,"T0")==0)||(strcmp(&phoneme,"T1")==0)||(strcmp(&phoneme,"T2")==0)) fprintf(out,"r",&word);
if((strcmp(&phoneme,"TH")==0)||(strcmp(&phoneme,"TH0")==0)||(strcmp(&phoneme,"TH1")==0)||(strcmp(&phoneme,"TH2")==0)) fprintf(out,"s",&word);
if((strcmp(&phoneme,"UH")==0)||(strcmp(&phoneme,"UH0")==0)||(strcmp(&phoneme,"UH1")==0)||(strcmp(&phoneme,"UH2")==0)) fprintf(out,"t",&word);
if((strcmp(&phoneme,"UW")==0)||(strcmp(&phoneme,"UW0")==0)||(strcmp(&phoneme,"UW1")==0)||(strcmp(&phoneme,"UW2")==0)) fprintf(out,"u",&word);
if((strcmp(&phoneme,"V")==0)||(strcmp(&phoneme,"V0")==0)||(strcmp(&phoneme,"V1")==0)||(strcmp(&phoneme,"V2")==0)) fprintf(out,"v",&word);
if((strcmp(&phoneme,"W")==0)||(strcmp(&phoneme,"W0")==0)||(strcmp(&phoneme,"W1")==0)||(strcmp(&phoneme,"W2")==0)) fprintf(out,"w",&word);
if((strcmp(&phoneme,"Y")==0)||(strcmp(&phoneme,"Y0")==0)||(strcmp(&phoneme,"Y1")==0)||(strcmp(&phoneme,"Y2")==0)) fprintf(out,"x",&word);
if((strcmp(&phoneme,"Z")==0)||(strcmp(&phoneme,"Z0")==0)||(strcmp(&phoneme,"Z1")==0)||(strcmp(&phoneme,"Z2")==0)) fprintf(out,"y",&word);
if((strcmp(&phoneme,"ZH")==0)||(strcmp(&phoneme,"ZH0")==0)||(strcmp(&phoneme,"ZH1")==0)||(strcmp(&phoneme,"ZH2")==0)) fprintf(out,"z",&word);
			
			p+=strlen(phoneme)+1;
		}
		printf("\n");
		fprintf(out,"\n");
	}
	
	if(out != NULL)
		fclose(out);
	if(in != NULL)
		fclose(in);
	
	return 0;
}