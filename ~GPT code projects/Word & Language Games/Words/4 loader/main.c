// A minimal Win32 console app

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#define kMaxChars	32
#define kNumWords	102100

struct words
{
  char word[kMaxChars],pron[kMaxChars];
}wordList[kNumWords],pronList[kNumWords]; 


int main( void ) {
	long 		c,p;
	char 		str [kMaxChars],word[kMaxChars],pron[kMaxChars];
	FILE		*pw,*wp;
			
	wp = fopen("words pron.txt", "r");
	if(wp == NULL)
	{
		printf("\nCannot open words pron.txt\n");
		exit(0);
	}
	
	pw = fopen("pron words.txt", "r");
	if(pw == NULL)
	{
		printf("\nCannot open pron words.txt\n");
		exit(0);
	}
	
	c=0;
	
	while(!feof(wp))	//	load the words
	{
		//	load the words
		fgets(str,kMaxChars,wp);		//	get the entry
		sscanf(str,"%s",&word);			//	get the word
		sscanf(&str[strlen(word)],"%s",&pron);	//	get the pronunciation
		strcpy(wordList[c].word,word);
		strcpy(wordList[c].pron,pron);
		
	//	load the pronunciations
		fgets(str,kMaxChars,pw);		//	get the entry
		sscanf(str,"%s",&pron);			//	get the pronunciation
		sscanf(&str[strlen(pron)],"%s",&word);	//	get the word
		strcpy(pronList[c].pron,pron);
		strcpy(pronList[c].word,word);
		
		
			if(c%10000==0) printf("%s	%s	%s %s\n",wordList[c].word,wordList[c].pron,pronList[c].pron,pronList[c].word);
		
		c++;
		if (c>=kNumWords) break;
	}
	printf("loaded\n");

	if(wp != NULL)
		fclose(wp);
	if(pw != NULL)
		fclose(pw);
	
	return 0;
}